# Keil uVision project myarm7code.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: myarm7code
  AfterMake: fromelf -cvf Objects\myarm7code.axf -o disasm.txt --vhx --32x1 -o mytestarm7.hex
  AfterMake: hex2sv mytestarm7.hex imem 0
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  group Source Group 1
    ./: morse.s
